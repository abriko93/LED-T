# IAR project My_STM32F4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: STM32F4XX_LIB; CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: My_STM32F4.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c Queue_Array.c stm32f4xx_it.c
  group CMSIS
    CMSIS/: system_stm32f4xx.c
  group EWARM
    EWARM/: startup_stm32f40xx.s
  group STM32F4XX_LIB
    STM32F4XX_LIB/: misc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
